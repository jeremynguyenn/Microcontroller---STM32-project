# Keil uVision project PROJECT.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F101C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PROJECT +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Source Group 1
    ./: 21146033-NguyentTrungNhan.c
    ../New folder/DIEU KHIEN MOTOR + LCD/: delay.h lcd.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
